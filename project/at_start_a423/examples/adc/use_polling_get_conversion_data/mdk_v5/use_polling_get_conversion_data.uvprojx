# Keil uVision project use_polling_get_conversion_data.uvprojx, settings and files
target use_polling_get_conversion_data (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: use_polling_get_conversion_data +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\inc;..\..\..\..\..\at32a423_board;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c main.c
  group bsp
    ../../../../../at32a423_board/: at32a423_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a423_gpio.c at32a423_misc.c at32a423_crm.c at32a423_dma.c at32a423_adc.c at32a423_usart.c at32a423_exint.c at32a423_scfg.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
  group readme
    ../: readme.txt
