# Keil uVision project deepsleep_i2c.uvprojx, settings and files
target deepsleep_i2c (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: deepsleep_i2c +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32a423_board;..\..\..\..\..\..\middlewares\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c main.c
  group bsp
    ../../../../../at32a423_board/: at32a423_board.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a423_crm.c at32a423_ertc.c at32a423_exint.c at32a423_gpio.c at32a423_misc.c at32a423_pwc.c at32a423_usart.c at32a423_i2c.c at32a423_dma.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
  group readme
    ../: readme.txt
