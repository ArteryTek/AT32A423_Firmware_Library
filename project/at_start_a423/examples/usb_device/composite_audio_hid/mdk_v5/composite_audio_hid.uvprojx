# Keil uVision project composite_audio_hid.uvprojx, settings and files
target composite_audio_hid (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: composite_audio_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32a423_board;..\inc;..\..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\..\middlewares\usbd_class\audio_hid;..\..\..\..\..\..\middlewares\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c main.c audio_codec.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group bsp
    ../../../../../at32a423_board/: at32a423_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32a423_dma.c at32a423_gpio.c at32a423_i2c.c at32a423_misc.c at32a423_spi.c at32a423_tmr.c at32a423_usart.c at32a423_usb.c at32a423_acc.c at32a423_crm.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
  group usbd_driver
    ../../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../../middlewares/usbd_class/audio_hid/: audio_hid_class.c audio_hid_desc.c
  group readme
    ../: readme.txt
