# Keil uVision project app_led3_toggle.uvprojx, settings and files
target app_led3_toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_led3_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\project\at32a423_board
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c iap.c tmr.c usart.c main.c
  group bsp
    ../../../../../project/at32a423_board/: at32a423_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32a423_crm.c at32a423_flash.c at32a423_gpio.c at32a423_usart.c at32a423_tmr.c at32a423_misc.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
  group readme
    ../: readme.txt
