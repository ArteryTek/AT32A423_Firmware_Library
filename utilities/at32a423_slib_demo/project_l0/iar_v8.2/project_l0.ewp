# IAR project project_l0.ewp, settings and files
configuration project_l0 (ARM, debug)
  General.OGChipSelectEditMenu: AT32A423VCT7_v2 ArteryTek - AT32A423VCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A423VCT7; USE_STDPERIPH_DRIVER; AT_START_A423_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32a423_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32A423xC_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32a423_board/: at32a423_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32a423.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32a423_crm.c at32a423_flash.c at32a423_gpio.c at32a423_misc.c at32a423_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32a423_clock.c at32a423_int.c main.c math_helper.c
