# Keil uVision project app_led4_toggle.uvprojx, settings and files
target app_led4_toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_led4_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\project\at32a423_board;..\inc;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8006000 size 0x3a000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c main.c hid_iap_user.c
  group bsp
    ../../../../../project/at32a423_board/: at32a423_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32a423_acc.c at32a423_crc.c at32a423_crm.c at32a423_usart.c at32a423_flash.c at32a423_gpio.c at32a423_misc.c at32a423_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
  group usbd_driver
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
