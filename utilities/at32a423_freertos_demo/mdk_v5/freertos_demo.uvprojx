# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32a423_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32a423_clock.c at32a423_int.c main.c include_port.c
  group bsp
    ../../../project/at32a423_board/: at32a423_board.c
  group firmware
    ../../../libraries/drivers/src/: at32a423_acc.c at32a423_adc.c at32a423_can.c at32a423_crc.c at32a423_crm.c at32a423_dac.c at32a423_debug.c at32a423_dma.c at32a423_ertc.c at32a423_exint.c at32a423_flash.c at32a423_gpio.c at32a423_i2c.c at32a423_misc.c at32a423_pwc.c at32a423_scfg.c at32a423_spi.c at32a423_tmr.c at32a423_usart.c at32a423_usb.c at32a423_wdt.c at32a423_wwdt.c at32a423_xmc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.0
  output: freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32a423_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
